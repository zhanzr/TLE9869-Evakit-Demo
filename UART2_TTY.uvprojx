# Keil uVision project UART2_TTY.uvprojx, settings and files
target tle9869_prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9869QXA20 Infineon
  pack: Infineon.TLE986x_DFP.1.3.2
  cpu: IRAM(0x18000000,0x1800) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,4) CPUTYPE("Cortex-M3") CLOCK(40000000) ELITTLE
  output: tty
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c include: .\app
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1800
  group App
    ./app/: main.c
  group asm
    ./app/: asm_test_1.s asm_test_2.s asm_test_3.s asm_test_4.s asm_test_5.s asm_test_6.s asm_test_7.s asm_test_8.s
software components: CMSIS:CORE 5.0.1, Device:ConfigWizard 1.8.6, Device:SDK:ADC2 0.1.5, Device:SDK:BOOTROM 0.2.1, Device:SDK:INT 0.1.4, Device:SDK:ISR 0.1.8, Device:SDK:PORT 0.5.1, Device:SDK:SCU 0.3.0, Device:SDK:UART 0.1.3, Device:SDK:WDT1 0.2.4, Device:Startup 1.0.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
